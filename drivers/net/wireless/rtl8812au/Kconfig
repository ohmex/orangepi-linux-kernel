## drivers/net/wireless/rtl8812au/Kconfig
```kconfig
config RTL8812AU_8821AU
	tristate "Realtek 8821/8812 AU USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8821AU
```
